# Keil uVision project DC motor trial_keil.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: DC motor trial_keil
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s main.c
    C:/ti/TivaWare_C_Series-2.1.2.111/inc/: tm4c123gh6pm.h
    C:/ti/TivaWare_C_Series-2.1.2.111/driverlib/: gpio.c pwm.c sysctl.c uart.c interrupt.c
    C:/ti/TivaWare_C_Series-2.1.2.111/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
